# Repository hra1129/Y8960_Cartridge

File readme.md:

# 概要
MSX2++用のAudio「Y8960」の開発用リポジトリです。
Y8960 Cartridge として開発しています。
MSX1/2/2+/turboR に装着することで利用可能です。

# Spec
- SSG (PSG) 2セット
- OPLL 1セット (MSX-MUSIC)
- OPL2 + ADPCM 1セット (MSX-AUDIO)
- SCC 1セット
- OPM 1セット

OPLL は、OPLL/OPLL-P/OPLL-X/VRC7相当 の ROM音色データを搭載しており、チャネルごとに選択可能です。
SSG/OPLL/OPL2/ADPCM/SCC はステレオ対応に拡張してあります。

# 残件
- 2個以上 Y8960 Cartridge を接続すると System Control Port がバス競合を起こすので2個以上付けちゃダメ
	→ 次の基板リビジョンで SystemControlPort をスイッチで切り離せるようにする予定
- BUSDIR が繋がっていないので、BUSDIR を見ている高級MSX2 で使えない
	→ 次の基板リビジョンで繋げる予定
- 細かいテスト

# FPGA
FPGAによるエミュレーションですので、リアルチップとは異なる音が鳴る可能性がありますが、そこのリアル性の追求は行いません。それらしい音が出たところで OK とします。
とはいえ、OPLL/OPL2/ADPCM/SCC/OPM は、再現性が高いと定評のある IP を利用させていただいています。各音源の原本の在処や、ライセンスに関しては、ソースコードの個々のフォルダに記載してありますので、そちらを参照ください。

# 免責事項
自動車等の乗り物や、医療、軍事等、人命にかかわるようなものへ、
一部または全部を転用する行為は厳禁です。

## KiCad design pcb/Y8960_Cartridge/Y8960_Cartridge.kicad_pcb

Parts:
C1, C3, C5, C6, C7, C8, C9, C10, C11, C12: 0.1uF; C_0402_1005Metric; LCSC C1525
C2: 15pF; C_0805_2012Metric; LCSC C63339
C4: 100uF; C_1210_3225Metric; LCSC C49066
D1, D2, D3, D4: LED; LED_0805_2012Metric; LCSC C84256
J1: I2S_CONN; PinHeader_1x06_P2.54mm_Vertical
J2: SOUNDIN; PinHeader_1x01_P2.54mm_Vertical
J3: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Vertical
J4: GND; PinHeader_1x01_P2.54mm_Vertical
Q1, Q2, Q3: NMOS; MOSFET(SMD); LCSC C458143
R1, R2, R3, R4, R5, R6, R7, R8, R13, R14, R15, R16, R17, R18: 4.7k; R_0805_2012Metric; LCSC C104350
R9, R10, R11, R12, R19, R21: 3.3k; R_0805_2012Metric; LCSC C26010
R20: 10k; R_0805_2012Metric; LCSC C17414
R24, R25, R26, R27: 470; R_0805_2012Metric; LCSC C17710
SW1, SW2: SlideSwitch
U1: TangPrimer25K(UPPER); LCSC C597938
U2: MSX Cartridge_1
U3: CLOCK; LCSC C387408
U4, U5, U6, U7: SSOP-24_5.3x8.2mm_P0.65mm; LCSC C19197
U8: QSPI-SRAM 4Mbit (8SOIC); LCSC C27585175
U9: TangPrimer25K(LOWER); LCSC C597938

Connections:
+3V3: C1.1, C3.1, C5.2, C7.2, C9.2, C11.2, J1.6, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.2, R18.2, R21.1, R24.1, R25.1, R26.1, R27.1, U1.2 (VCCIO2/3), U1.4 (VCCIO2/3), U1.46 (VDD_3V3), U1.48 (VDD_3V3), U1.50 (VDD_3V3), U3.1 (En), U3.4 (3V3), U4.1 (VCCA), U5.1 (VCCA), U6.1 (VCCA), U7.1 (VCCA), U8.8 (VCC), U9.84 (VCCIO0/1), U9.86 (VCCIO0/1), U9.89 (VCCIO6/7), U9.91 (VCCIO6/7)
+5V: C4.1, C6.2, C8.2, C10.2, C12.2, J3.4, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, U1.52 (VDD_5V), U1.54 (VDD_5V), U1.56 (VDD_5V), U1.58 (VDD_5V), U1.60 (VDD_5V), U2.45 (+5V), U2.47 (+5V), U4.23 (VCCB), U4.24 (VCCB), U5.23 (VCCB), U5.24 (VCCB), U6.23 (VCCB), U6.24 (VCCB), U7.23 (VCCB), U7.24 (VCCB)
A0: U2.28 (A0), U6.14 (B8)
A1: U2.27 (A1), U6.15 (B7)
A2: U2.30 (A2), U6.16 (B6)
A3: U2.29 (A3), U6.17 (B5)
A4: U2.32 (A4), U6.18 (B4)
A5: U2.31 (A5), U6.19 (B3)
A6: U2.22 (A6), U6.20 (B2)
A7: U2.21 (A7), U6.21 (B1)
A8: U2.24 (A8), U5.21 (B1)
A9: U2.17 (A9), U5.20 (B2)
A10: U2.20 (A10), U5.19 (B3)
A11: U2.19 (A11), U5.18 (B4)
A12: U2.23 (A12), U5.17 (B5)
A13: U2.26 (A13), U5.16 (B6)
A14: U2.25 (A14), U5.15 (B7)
A15: U2.18 (A15), U5.14 (B8)
AUDIO_BCLK: J1.2, R10.2, U9.114 (AUDIO_BCLK)
AUDIO_LRCLK: J1.4, R11.2, U9.116 (AUDIO_LRCLK)
AUDIO_MCLK: J1.1, R9.2, U9.112 (AUDIO_MCLK)
AUDIO_SDATA: J1.3, R12.2, U9.118 (AUDIO_SDATA)
CLK28M: C2.1, U3.3 (CLK), U9.64 (CLK28M)
D0: R1.2, U2.34 (D0), U4.14 (B8)
D1: R5.2, U2.33 (D1), U4.15 (B7)
D2: R2.2, U2.36 (D2), U4.16 (B6)
D3: R6.2, U2.35 (D3), U4.17 (B5)
D4: R3.2, U2.38 (D4), U4.18 (B4)
D5: R7.2, U2.37 (D5), U4.19 (B3)
D6: R4.2, U2.40 (D6), U4.20 (B2)
D7: R8.2, U2.39 (D7), U4.21 (B1)
DIPSW0: SW1.2, U9.77 (DIPSW0(READY))
DIPSW1: SW2.2, U9.83 (DIPSW1)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, J1.5, J3.1, J3.2, J4.1, Q1.3 (S), Q2.3 (S), Q3.3 (S), R19.2, R20.2, SW1.1, SW2.1, U1.1 (GND), U1.19 (GND), U1.29 (GND), U1.35 (GND), U1.41 (GND), U1.47 (GND), U1.53 (GND), U1.59 (GND), U2.41 (GND), U2.43 (GND), U3.2 (GND), U4.11 (GND), U4.12 (GND), U4.13 (GND), U4.22 (OEn), U5.2 (DIR), U5.11 (GND), U5.12 (GND), U5.13 (GND), U5.22 (OEn), U6.2 (DIR), U6.11 (GND), U6.12 (GND), U6.13 (GND), U6.22 (OEn), U7.2 (DIR), U7.11 (GND), U7.12 (GND), U7.13 (GND), U7.22 (OEn), U8.4 (VSS), U9.61 (GND), U9.62 (GND), U9.75 (GND), U9.87 (GND), U9.88 (GND), U9.105 (GND), U9.110 (GND), U9.119 (GND), U9.120 (GND)
JTAG_TCK: J3.6, U1.21 (JTAG_TCK)
JTAG_TDI: J3.8, U1.27 (JTAG_TDI)
JTAG_TDO: J3.10, U1.25 (JTAG_TDO)
JTAG_TMS: J3.12, U1.23 (JTAG_TMS)
unnamed: D1.2 (A), R24.2
unnamed: D1.1 (K), U9.111 (LED0)
unnamed: D2.2 (A), R25.2
unnamed: D2.1 (K), U9.113 (LED1)
unnamed: D3.2 (A), R26.2
unnamed: D3.1 (K), U9.115 (LED2)
unnamed: D4.2 (A), R27.2
unnamed: D4.1 (K), U9.117 (LED3)
unnamed: J2.1, U2.49 (SUNDIN)
unnamed: U2.44 (SW1), U2.46 (SW2)
SLOT_A0: U6.10 (A8), U9.63 (SLOT_A0)
SLOT_A1: U6.9 (A7), U9.65 (SLOT_A1)
SLOT_A2: U6.8 (A6), U9.67 (SLOT_A2)
SLOT_A3: U6.7 (A5), U9.69 (SLOT_A3)
SLOT_A4: U6.6 (A4), U9.71 (SLOT_A4)
SLOT_A5: U6.5 (A3), U9.73 (SLOT_A5)
SLOT_A6: U6.4 (A2), U9.93 (SLOT_A6)
SLOT_A7: U6.3 (A1), U9.95 (SLOT_A7)
SLOT_A8: U5.3 (A1), U9.82 (SLOT_A8)
SLOT_A9: U5.4 (A2), U9.80 (SLOT_A9)
SLOT_A10: U5.5 (A3), U9.78 (SLOT_A10)
SLOT_A11: U5.6 (A4), U9.76 (SLOT_A11)
SLOT_A12: U5.7 (A5), U9.74 (SLOT_A12)
SLOT_A13: U5.8 (A6), U9.72 (SLOT_A13)
SLOT_A14: U5.9 (A7), U9.108 (SLOT_A14)
SLOT_A15: U5.10 (A8), U9.106 (SLOT_A15)
SLOT_BUSDIR: U4.2 (DIR), U9.103 (SLOT_BUSDIR)
SLOT_D0: U4.10 (A8), U9.90 (SLOT_D0)
SLOT_D1: U4.9 (A7), U9.92 (SLOT_D1)
SLOT_D2: U4.8 (A6), U9.94 (SLOT_D2)
SLOT_D3: U4.7 (A5), U9.96 (SLOT_D3)
SLOT_D4: U4.6 (A4), U9.98 (SLOT_D4)
SLOT_D5: U4.5 (A3), U9.100 (SLOT_D5)
SLOT_D6: U4.4 (A2), U9.102 (SLOT_D6)
SLOT_D7: U4.3 (A1), U9.104 (SLOT_D7)
SLOT_DATA_DIR: Q1.2 (G), R20.1
SLOT_INTR: Q3.2 (G), R19.1, U9.97 (SLOT_INTR)
SLOT_IORQ_N: U7.7 (A5), U9.68 (SLOT_IORQ_N)
SLOT_M1_N: U1.6 (SLOT_M1_N), U7.9 (A7)
SLOT_MERQ_N: U7.6 (A4), U9.70 (SLOT_MERQ_N)
SLOT_RD_N: U7.3 (A1), U9.109 (SLOT_RD_N)
SLOT_RESET_N: U7.5 (A3), U9.101 (SLOT_RESET_N)
SLOT_SLTSL_N: U7.8 (A6), U9.66 (SLOT_SLTSL_N)
SLOT_WAIT: Q2.2 (G), R21.2, U9.99 (SLOT_WAIT)
SLOT_WR_N: U7.4 (A2), U9.107 (SLOT_WR_N)
SRAM_CS_N: R13.2, U1.9 (SRAM_CS_N), U8.1 (~CS)
SRAM_SCLK: R14.2, U1.7 (SRAM_SCLK), U8.6 (SCK)
SRAM_SIO0: R15.2, U1.11 (SRAM_SIO0), U8.5 (SI/SIO0)
SRAM_SIO1: R16.2, U1.5 (SRAM_SIO1), U8.2 (SO/SIO1)
SRAM_SIO2: R17.1, U1.15 (SRAM_SIO2), U8.3 (SIO2)
SRAM_SIO3: R18.1, U1.17 (SRAM_SIO3), U8.7 (~HOLD/SIO3)
UART_RX: J3.5, U9.79 (UART_RX)
UART_TX: J3.7, U9.81 (UART_TX)
/BUSDIR: Q1.1 (D), U2.10 (/BUSDIR)
/INT: Q3.1 (D), U2.8 (/INT)
/IORQ: U2.11 (/IORQ), U7.17 (B5)
/M1: U2.9 (/M1), U7.15 (B7)
/MERQ: U2.12 (/MERQ), U7.18 (B4)
/RD: U2.14 (/RD), U7.21 (B1)
/RESET: U2.15 (/RESET), U7.19 (B3)
/RFSH: U2.6 (/RFSH), U7.14 (B8)
/SLTSL: U2.4 (/SLTSL), U7.16 (B6)
/WAIT: Q2.1 (D), U2.7 (/WAIT)
/WR: U2.13 (/WR), U7.20 (B2)

Notes on the sheet:
※正論理
RTS
TangPrimer20K Lite に付属する UARTモジュールのピンアサイン
TMS
TO236AB Vgs(th) = 1.25V
TDO
3V3
TDR
FPGAサイドの TXO/RXO を、 コネクタの RX/TX にクロスで接続する。
SLOT_WAIT : 1 or HiZ → /WAIT=0 0 → /WAIT=HiZ
GND
TDI
SLOT_DATA_DIR 0: CPU → Cartridge (WRITE) 1: CPU ← Cartridge (READ)
TCK
SLOT_INT : 1 → /INT=0 0 or HiZ → /INT=HiZ
/BUSDIR 1: CPU → Cartridge (WRITE) 0: CPU ← Cartridge (READ)

Board: 2 copper layers, 95.2 x 65.4 mm, 61 parts (0 on the bottom side), 102 nets.

Other parts of the board:
G1: LOGO; msx_logo_15x5p8
G2: LOGO; usa_10x7

File pcb/Y8960_Cartridge/parts.txt:

Part#                            Maker           Name                 JLCPCB Part #
C1, C3, C5-C12: 0.1uF            -               0402                 C1525             https://jlcpcb.com/partdetail/1877-CL05B104KO5NNNC/C1525
C2: 15pF                         -               0805                 C63339            https://jlcpcb.com/partdetail/64402-0805CG150J500NT/C63339
C4: 100uF                        -               1210                 C49066            https://jlcpcb.com/partdetail/50074-CL32A107MQVNNNE/C49066
D1-D4: LED(RED)                  -               0805                 C84256            https://jlcpcb.com/partdetail/85425-NCD0805R1/C84256
J1: Pin Header                   -               -                    -
J2, J4: Pin Header               -               -                    -
J3: Pin Socket                   -               -                    -
Q1-Q3: NMOS FET                  -               PMV130ENEAR          C458143           https://jlcpcb.com/partdetail/Nexperia-PMV130ENEAR/C458143
R1-R8, R13-R18: 4.7k             -               0805                 C104350           https://jlcpcb.com/partdetail/RALEC-RTT05472JTP/C104350
R9-R12, R19, R21: 3.3k           -               0805                 C26010            https://jlcpcb.com/partdetail/26753-0805W8F3301T5E/C26010
R20: 10k                         -               0805                 C17414            https://jlcpcb.com/partdetail/18102-0805W8F1002T5E/C17414
R24-R27: 470                     -               0805                 C17710            https://jlcpcb.com/partdetail/18398-0805W8F4700T5E/C17710
SW1, SW2:                        -               -                    -
U1, U9: TangPrimer25K Connector  HRS(Hirose)     DF40C-60DS-0.4V(51)  C597938           https://jlcpcb.com/partdetail/HRS_Hirose-DF40C_60DS_0_4V_51/C597938
U2: MSX Cartridge Edge           -               -                    -                 -
U3: 28.63636MHz Clock            Shenzhen SCTF   S3D28.636360B20F30T  C387408           https://jlcpcb.com/partdetail/361496-S3D28636360B20F30T/C387408
U4-U7: Level Shifter             TI              SN74LVC8T245DBR      C19197            https://jlcpcb.com/partdetail/TexasInstruments-SN74LVC8T245D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
U8: SRAM 4Mbit                   Microchip Tech  23AA04M-I/SN         C27585175         https://jlcpcb.com/partdetail/MicrochipTech-23AA04M_ISN/C27585175

## Commit log (part)

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2026-01-10 Added specifications
2026-01-10 Uploaded
2026-01-18 Bugfix MSX-TIMER
    不等号の向きが逆だったのを修正
2026-01-18 Bugfix MSX-TIMER
    コンパイルエラーが出ていたのに気づいていなかったバグを修正
    カウンターの比較がおかしかったバグを修正
2026-01-18 Updated
    テストベンチのバッチ更新
2026-01-18 Bugfix En
    En = 0 でも、カウント値が大きな値になってると、割り込みが発生してしまうバグを修正。

Notices in the files:
pcb/Y8960_Cartridge/Y8960_Cartridge.kicad_pcb:
(C)2026 HRA!
